# Keil uVision project AT_Flash.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.0.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT_Flash
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User\Inc;..\common\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/Src/: AT_flash.c main.c AT_START_F413_V1.2.c at32f403a_int.c
    ../common/Src/: FLASH.c
software components: CMSIS:CORE 5.6.0, Device:at32f413_conf 2.0.0, Device:at32f413_firmware_library:crm 2.0.0, Device:at32f413_firmware_library:flash 2.0.0, Device:at32f413_firmware_library:gpio 2.0.0, Device:at32f413_firmware_library:misc 2.0.0, Device:startup 2.0.0
